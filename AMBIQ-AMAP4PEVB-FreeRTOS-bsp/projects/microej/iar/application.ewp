# IAR project application.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4P; AM_PACKAGE_BGA; INCLUDE_uxTaskPriorityGet=1; USE_TSI_MALLOC; PLATFORM=apollo4p_nemagfx; NEMAGFX_SDK_PATH=../../../sdk/third_party/ThinkSi/NemaGFX_SDK; USE_TOUCH; HIGH_PERFORMANCE_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\core\inc; ..\main\inc; ..\freertos\inc; ..\microej-util\inc; ..\platform\inc; ..\trace\inc; ..\ui\inc; ..\..\..\sdk\devices; ..\..\..\sdk\utils; ..\..\..\sdk\mcu\apollo4p; ..\..\..\sdk\mcu\apollo4p\hal; ..\..\..\sdk\mcu\apollo4p\regs; ..\..\..\sdk\CMSIS\ARM\Include; ..\..\..\sdk\boards\apollo4p_evb_disp_shield_rev2\bsp; ..\..\..\sdk\CMSIS\AmbiqMicro\Include; ..\..\..\sdk\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\sdk\third_party\FreeRTOSv10.1.1\Source\portable\IAR\ARM_CM4F; ..\..\..\thirdparty\systemview\inc; ..\..\..\sdk\third_party\ThinkSi\config\apollo4p_nemagfx; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\sdk\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\validation\tests\core\c\inc; ..\validation\framework\c\utils\inc; ..\validation\framework\c\embunit\embUnit; ..\..\CoreMark; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc; ..\core-qualification\inc; ..\validation\port\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\main\inc; ..\..\..\sdk\third_party\SystemView_V320\Src\Config
  OBJCOPY.OOCOutputFile: application.bin
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group project/core
    ../core/src/: fault_handlers.c LLBSP_generic.c LLEXT_RES_impl.c LLMJVM_FreeRTOS.c microej_main.c microej_time_hard.c microej_validation.c
  group project/libs
    ../../../sdk/boards/apollo4p_evb_disp_shield_rev2/bsp/iar/bin/: libam_bsp.a
    ../../../sdk/mcu/apollo4p/hal/mcu/iar/bin/: libam_hal.a
    ../platform/lib/: microejapp.o microejruntime.a
  group project/main
    ../main/src/: FreeRTOS_hooks.c main.c power.c
  group project/microej-util
    ../microej-util/src/: interrupts.c
  group project/startup
    ./: startup_iar.c
  group project/trace
    ../trace/src/: LLMJVM_MONITOR_sysview.c LLTRACE_sysview.c trace_platform.c
  group project/ui
    ../ui/src/: buttons_driver.c event_generator.c LLDW_PAINTER_impl.c LLUI_DISPLAY_HEAP_impl.c LLUI_DISPLAY_impl.c LLUI_INPUT_impl.c LLUI_INPUT_LOG_impl.c LLUI_LED_impl.c LLUI_PAINTER_impl.c microui_rotation.c touch_helper.c touch_manager.c ui_drawing_nema.c
  group project/validation/port
    ../validation/port/src/: core_portme.c cvt.c ee_printf.c microej_core_qualification.c
  group project/validation/tests
    ../validation/tests/core/c/src/: t_core_core_benchmark.c t_core_main.c t_core_print.c t_core_ram.c t_core_time_base.c x_impl_core_benchmark.c x_impl_ram_checks.c x_impl_ram_speed.c x_ram_checks.c x_ram_speed.c
  group project/validation/utils
    ../validation/framework/c/utils/src/: u_print.c u_time_base.c
  group sdk/devices
    ../../../sdk/devices/: am_devices_button.c am_devices_dsi_rm67162.c am_devices_led.c am_devices_mspi_psram_aps12808l.c am_devices_tma525.c
  group sdk/hal
    ../../../sdk/mcu/apollo4p/hal/: am_hal_pwrctrl.c am_hal_stimer.c
  group sdk/nema
    ../../../sdk/third_party/ThinkSi/config/apollo4p_nemagfx/iar/bin/: lib_nema_apollo4p_nemagfx.a
    ../../../sdk/third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group sdk/thirdparty/freertos
    ../../../sdk/third_party/FreeRTOSv10.1.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../sdk/third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../sdk/third_party/FreeRTOSv10.1.1/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group sdk/utils
    ../../../sdk/utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group thirdparty/CoreMark
    ../../CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group thirdparty/EmbUnit
    ../validation/framework/c/embunit/embUnit/: AssertImpl.c AssertImpl.h config.h embUnit.h HelperMacro.h RepeatedTest.c RepeatedTest.h stdImpl.c stdImpl.h Test.h TestCaller.c TestCaller.h TestCase.c TestCase.h TestListener.h TestResult.c TestResult.h TestRunner.c TestRunner.h TestSuite.c TestSuite.h
  group thirdparty/systemview
    ../thirdparty/systemview/src/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group thirdparty/systemview-freertos
    ../thirdparty/systemview-freertos/src/: SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
